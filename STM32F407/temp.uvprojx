# Keil uVision project temp.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: temp
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\HARTDWARE\LED;.\SYS\DELAY;.\HARTDWARE\KEY;.\SYS\sys;.\HARTDWARE\BEEP;.\HARTDWARE\EXIT;.\HARTDWARE\UART;.\HARTDWARE\IWDOG;.\HARTDWARE\TIMER;.\HARTDWARE\DHT11;.\HARTDWARE\IIC;.\HARTDWARE\AT24C02;.\HARTDWARE\OLED;.\HARTDWARE\SPI;.\HARTDWARE\W25Q64;.\HARTDWARE\ADC;.\HARTDWARE\light;.\HARTDWARE\voltage;.\HARTDWARE\cJSON;.\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c
  group HARDWARE
    ./HARTDWARE/LED/: led.c
    ./HARTDWARE/KEY/: key.c
    ./HARTDWARE/BEEP/: beep.c
    ./HARTDWARE/EXIT/: exit.c
    ./HARTDWARE/UART/: uart.c
    ./HARTDWARE/IWDOG/: iwdog.c
    ./HARTDWARE/TIMER/: timer.c
    ./HARTDWARE/DHT11/: dht11.c
    ./HARTDWARE/IIC/: iic.c
    ./HARTDWARE/AT24C02/: at24c02.c
    ./HARTDWARE/OLED/: oled.c
    ./HARTDWARE/SPI/: spi.c
    ./HARTDWARE/W25Q64/: w25q64.c
    ./HARTDWARE/ADC/: adc.c
    ./HARTDWARE/light/: light.c
    ./HARTDWARE/voltage/: voltage.c
    ./HARTDWARE/cJSON/: cJSON.c
  group SYS
    ./SYS/DELAY/: delay.c
    ./SYS/sys/: sys.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:IWDG 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
